# IAR project STM32G030Pro.ewp, settings and files
configuration STM32G030Pro (ARM, debug)
  General.OGChipSelectEditMenu: STM32G030K8 ST STM32G030K8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\Src; ..\Drivers\STM32G0xx_HAL_Driver\Inc; ..\Drivers\STM32G0xx_HAL_Driver\Inc\Legacy; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32G0xx\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: super_block.bin
  ILINK.IlinkOutputFile: STM32G030Pro.out
  ILINK.IlinkIcfFile: stm32g030xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_ll_dma.c stm32g0xx_ll_rcc.c
  group EWARM
    ./: startup_stm32g030xx.s
  group Src
    ../Src/: audio.c boot_anim.c rotate_anim.c GlobalVar.c GPIO.c key_detect.c main.c SM16208.c stm32g0xx_hal_msp.c stm32g0xx_it.c system_stm32g0xx.c timer.c
